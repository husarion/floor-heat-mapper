Commit message: Callibrating navigating

File: rosbot/robot_model/urdf/rosbot.urdf (robot description, URDF)
Before this commit: robot rosbot, 15 links, 13 joints
Links:
- removed link thermal_camera_support_link
